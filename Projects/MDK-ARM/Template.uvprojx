# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf.exe   --bin -o  ..\..\Output\Template.bin ..\..\Output\Template.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Core;..\..\User;..\..\Drivers\STM32F10x_FWLib\inc;..\..\Drivers\System\sys;..\..\Drivers\System\delay;..\..\Drivers\Hardware\Flash;..\..\Drivers\Hardware\Usart;..\..\Drivers\Hardware\WDG;..\..\Bsp\Esp8266;..\..\Bsp\Iap;..\..\Bsp\Key;..\..\Bsp\Lcd;..\..\Bsp\Led;..\..\Bsp\Motor;..\..\Bsp\Ws2812;..\..\Bsp\Steering;..\..\Middlewares\CRC;..\..\Rtos\RT-Thread\components\finsh;..\..\Rtos\RT-Thread\include;..\..\App\Arm_Thread;..\..\App\Display_Thread;..\..\App\Transfer_Thread;..\..\App\Led_WDG;..\..\App\Key_Thread
  memory RVCT4: ROM 0x8007800 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../User/: main.c stm32f10x_it.c system_stm32f10x.c board.c rtconfig.h
  group Core
    ../../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Drivers/STM32F10x_FWLib
    ../../Drivers/STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group Drivers/System
    ../../Drivers/System/delay/: delay.c
    ../../Drivers/System/sys/: sys.c
  group Drivers/Hardware
    ../../Drivers/Hardware/Flash/: Flash.c
    ../../Drivers/Hardware/Usart/: Usart.c
    ../../Drivers/Hardware/WDG/: WDG.c
  group Middlewares
    ../../Middlewares/list/: LoopList.c List.c
    ../../Middlewares/LobotServo/: LobotServo.c
    ../../Middlewares/CRC/: CRC.c
  group Bsp
    ../../Bsp/Esp8266/: Esp8266.c
    ../../Bsp/Iap/: Iap.c
    ../../Bsp/Led/: Led.c
    ../../Bsp/Ws2812/: Ws2812.c
    ../../Bsp/Motor/: Motor.c
    ../../Bsp/Lcd/: LcdInit.c
    ../../Bsp/Key/: Key.c
    ../../Bsp/Steering/: Steering.c
  group App
    ../../App/Arm_Thread/: Arm_Thread.c
    ../../App/Transfer_Thread/: Transfer_Thread.c
    ../../App/Display_Thread/: Display_Thread.c
    ../../App/Led_WDG/: Led_WDG.c
    ../../App/Key_Thread/: Key_Thread.c
  group RTT/Source
    ../../Rtos/RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTT/Ports
    ../../Rtos/RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
